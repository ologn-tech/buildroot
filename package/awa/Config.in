## package/awa/Config.in
```kconfig
config BR2_PACKAGE_AWA
	bool "awa"
	select BR2_PACKAGE_LIBUSBGX
	help
	  Awa - Android Auto Wireless Adapter
```
